Commit message: update

File: mycobot_description/urdf/mecharm/mecharm_aikit.urdf (robot description, URDF)
Before this commit: robot firefighter, 8 links, 7 joints
Links:
- link env: geometry visual mesh filename=package://mycobot_description/urdf/260_pi/suit_env.dae scale=1.4 1.4 1.4
